** sch_path: macros/heichips26_analog_project/macros/inverter/schematic/xschem/inverter.sch
**.subckt inverter vin VDD VSS vout [expr {$lvs_ignore ? {VDD} : {nwell}}] [expr {$lvs_ignore ? {VSS} : {psub}}]
*.ipin vin
*.iopin VDD
*.iopin VSS
*.iopin vout
*.iopin [expr {$lvs_ignore ? {VDD} : {nwell}}]
*.iopin [expr {$lvs_ignore ? {VSS} : {psub}}]
XMdummy1 VSS VSS VSS [expr {$lvs_ignore ? {VSS} : {psub}}] sg13_lv_nmos w=2.0u l=1.0u ng=2 m=1 mm_ok=1
XMdummy2 VDD VDD VDD [expr {$lvs_ignore ? {VDD} : {nwell}}] sg13_lv_pmos w=12.0u l=1.0u ng=2 m=1 mm_ok=1
XM1 vout vin VSS [expr {$lvs_ignore ? {VSS} : {psub}}] sg13_lv_nmos w=20.0u l=1.0u ng=20 m=1 mm_ok=1
XM2 vout vin VDD [expr {$lvs_ignore ? {VDD} : {nwell}}] sg13_lv_pmos w=120.0u l=1.0u ng=20 m=1 mm_ok=1
XR1 VDD [expr {$lvs_ignore ? {VDD} : {nwell}}] ntap1 R=2.842 w=32.68e-6 l=8.02e-6 rw=0.3e-6
XR2 VSS [expr {$lvs_ignore ? {VSS} : {psub}}] ptap1 R=3.214 w=32.68e-6 l=3.38e-6 rw=0.3e-6
**.ends
.end
