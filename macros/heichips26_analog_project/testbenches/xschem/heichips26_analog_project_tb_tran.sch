** sch_path: macros/heichips26_analog_project/testbenches/xschem/heichips26_analog_project_tb_tran.sch
**.subckt heichips26_analog_project_tb_tran
VPWR VPWR GND {VPWR}
vsine analog_0 GND sin({Vcm} 10m 1k)
C1 analog_1 GND {Cload} m=1
C2 analog_2 GND {Cload} m=1
x1 VPWR VAPWR GND net1 net2 net3 net4 net5 net6 net7 net8 net9 net10 net42 net11 net12 net13 net14
+ net15 net16 net17 uio_in_0 net18 net19 net20 net21 net22 net23 net24 net25 net26 net27 net28 net29 net30
+ net31 net32 net33 net34 net35 net36 net37 net38 net39 net40 net41 analog_2 analog_1 analog_0
+ heichips26_analog_project
* noconn #net26
* noconn #net27
* noconn #net28
* noconn #net29
* noconn #net30
* noconn #net31
* noconn #net32
* noconn #net33
* noconn #net34
* noconn #net35
* noconn #net36
* noconn #net37
* noconn #net38
* noconn #net39
* noconn #net40
* noconn #net41
* noconn #net1
* noconn #net2
* noconn #net3
* noconn #net4
* noconn #net5
* noconn #net6
* noconn #net7
* noconn #net8
* noconn #net9
* noconn #net10
* noconn #net11
* noconn #net12
* noconn #net13
* noconn #net14
* noconn #net15
* noconn #net16
* noconn #net17
* noconn #net18
* noconn #net19
* noconn #net20
* noconn #net21
* noconn #net22
* noconn #net23
* noconn #net24
* noconn #net25
VAPWR VAPWR GND {VAPWR}
vpulse uio_in_0 GND pulse(0 {VPWR} 0 10n 10n 500u 1m)
* noconn #net42
**** begin user architecture code


.include ../../../netlist/pex/heichips26_analog_project_magic_pex_3.spice
.param VPWR=1.5
.csparam VPWR=VPWR
.param VAPWR=1.5
.csparam VAPWR=VAPWR
.param Vcm=VAPWR/2
.param temp=27
.param Cload=10p
.param Rload=1k
.options savecurrents klu method=gear reltol=1e-3 abstol=1e-12 gmin=1e-12
.control

save all

* Operating Point Analysis
op
remzerovec
write @schname\.raw
set appendwrite

* Transient Analysis
tran 1u 4m
write @schname\.raw

* Plotting
plot i(VPWR)
plot i(VAPWR)
plot analog_0 analog_1
plot uio_in_0 analog_2

* Measurements
meas tran vin_peak MAX v(analog_0)
meas tran vout_peak MAX v(analog_1)

let Adm = vout_peak / vin_peak
let Adm_dB = vdb(Adm)
print Adm_dB

meas tran vout_pp_max MAX v(analog_1)
meas tran vout_pp_min MIN v(analog_1)
let vout_pp = vout_pp_max - vout_pp_min
print vout_pp

* Write Data
unset appendwrite
set wr_vecnames
set wr_singlescale
wrdata ../plot_simulations/data/@schname\.txt  v(uio_in_0) v(analog_0) v(analog_1) v(analog_2)

*quit
.endc



.lib cornerMOSlv.lib mos_tt
.lib cornerMOShv.lib mos_tt
.lib cornerRES.lib res_typ
.lib cornerDIO.lib dio_tt

 .include [file rootname [xschem get schname]].save

**** end user architecture code
**.ends
.GLOBAL GND
.end
